# IAR project BlueBasic.ewp, settings and files
configuration CC2541 (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: INT_HEAP_LEN=4096; BLUEBASIC_MEM=2048; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; FEATURE_BOOST_CONVERTER=P2_0
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\Source; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\SimpleProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; $OBJ_DIR$
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  prebuild: cmd /c echo #define BUILD_TIMESTAMP "$CONFIG_NAME$/%date:~-4%%date:~4,2%%date:~7,2%%time:~0,2%%time:~3,2%%time:~6,2%" > "$OBJ_DIR$\timestamp.h
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2540 (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: INT_HEAP_LEN=4096; BLUEBASIC_MEM=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; TARGET_CC2540=TRUE; FEATURE_BOOST_CONVERTER=P2_0
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\Source; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; $OBJ_DIR$
configuration CC2541-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=4096; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=0; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; FEATURE_BOOST_CONVERTER=P2_0
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\Source; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\SimpleProfile; ..\..\Profiles\SimpleProfile\CC254x; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; $OBJ_DIR$
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" CC2541 "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  CC2541-ImgB  CC2541
  XLINK.XclFile: F:\github\BlueBasic\BLE-CC254x-1.4.0\Projects\ble\common\cc2540\cc254x_f256_imgB.xcl
configuration CC2540-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=4096; BLUEBASIC_MEM=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2540=TRUE; xFEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; FEATURE_BOOST_CONVERTER=P2_0
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\Source; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; $OBJ_DIR$
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" CC2540 "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2540-ImgA CC2540-ImgB CC2540
  XLINK.XclFile: as above
configuration Petra (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=4096; BLUEBASIC_MEM=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_PETRA=TRUE; xFEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" Petra "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" Petra Petra Petra
  XLINK.XclFile: as above
configuration BlueSolar (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueSolar"; kMfrName="blue-battery.com"; BLUESOLAR=TRUE; INT_HEAP_LEN=4352; BLUEBASIC_MEM=3328; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=32; xHAL_UART_ISR=2; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; FEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=0; PROCESS_SERIAL_DATA; xOSALMEM_METRICS=TRUE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\hal\target\CC2541ARC; ..\..\..\..\Components\osal\include; ..\Source; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\SimpleProfile; ..\..\Profiles\SimpleProfile\CC254x; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; $OBJ_DIR$
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueSolar "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueSolar BlueSolar
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration BlueBattery (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4352; BLUEBASIC_MEM=3328; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=FALSE; xHAL_UART_DMA=1; xHAL_UART_DMA_RX_MAX=32; xHAL_UART_DMA_TX_MAX=32; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; FEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=0; PROCESS_SERIAL_DATA; xOSALMEM_METRICS=TRUE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueBattery "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueBattery BlueBattery
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration BlueSteca (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueSteca"; kMfrName="blue-battery.com"; DEVINFO_PID=0x0500; BLUESOLAR=TRUE; BLUESTECA=TRUE; INT_HEAP_LEN=4096; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xHAL_UART=TRUE; xHAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=0; HAL_UART_DMA_TX_MAX=0; HAL_I2C=TRUE; HAL_I2C_SLAVE; HAL_I2C_BUF_MAX=7; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; FEATURE_BOOST_CONVERTER=P2_0
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueSteca "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueSteca BlueSteca
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration BlueBattery-D1 (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4352; BLUEBASIC_MEM=3328; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=32; HAL_UART_ISR=2; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; FEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=0; PROCESS_SERIAL_DATA; xOSALMEM_METRICS=TRUE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=TRUE
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueBattery-D1 "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueBattery-D1 BlueBattery-D1
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration BlueBattery-MPPT (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4352; BLUEBASIC_MEM=3328; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=32; HAL_UART_ISR=2; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=FALSE; FEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=1; PROCESS_SERIAL_DATA; PROCESS_MPPT; MPPT_AS_VOT=1; xOSALMEM_METRICS=TRUE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=TRUE
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueBattery-MPPT "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueBattery-MPPT BlueBattery-MPPT
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
  group APP
    ../Source/: BlueBasic.c BlueBasic.h BlueBasic_Flashstore.c BlueBasic_Interpreter.c BlueBasic_Main.c cc2540.asm os.c os.h OSAL_BlueBasic.c victron_mppt.c
  group HAL/Common
    ../../../../COMPONENTS/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_led.c
    ../../../../COMPONENTS/hal/target/CC2540EB/: hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2541ARC/Drivers
    ../../../../COMPONENTS/hal/target/CC2541ARC/: hal_i2c.c
  group HAL/Target/CC2541ARC/Includes
    ../../../../COMPONENTS/hal/target/CC2541ARC/: hal_i2c.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib CC2541_BLE_peri_observ.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../COMPONENTS/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../COMPONENTS/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../COMPONENTS/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/Roles/CC254x/: observer.c observer.h peripheral.c peripheral.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
  group XLINK
    ../../common/cc2540/: cc254x_f256_imgB.xcl

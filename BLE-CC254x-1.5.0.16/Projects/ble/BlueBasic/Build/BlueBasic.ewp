# IAR project BlueBasic.ewp, settings and files
configuration BlueSolar (8051)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: kProduct="BlueSolar"; kMfrName="blue-battery.com"; BLUESOLAR=TRUE; INT_HEAP_LEN=4400; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=32; HAL_UART_ISR=2; xPOWER_SAVING; PLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; FEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=0; PROCESS_SERIAL_DATA; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\hal\target\CC2541ARC; ..\..\..\..\Components\osal\include; ..\Source; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\SimpleProfile; ..\..\Profiles\SimpleProfile\CC254x; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; $OBJ_DIR$
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueSolar "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueSolar BlueSolar
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration BlueSolar_sleep (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueSolar"; kMfrName="blue-battery.com"; BLUESOLAR=TRUE; INT_HEAP_LEN=4400; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=32; xHAL_UART_ISR=2; POWER_SAVING; PLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; xFEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=0; PROCESS_SERIAL_DATA; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueSolar_sleep "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueSolar_sleep BlueSolar_sleep
configuration BlueBattery (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4400; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xHAL_UART=TRUE; xHAL_UART_DMA=1; xHAL_UART_DMA_RX_MAX=32; xHAL_UART_DMA_TX_MAX=32; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; FEATURE_BOOST_CONVERTER=P2_0; FEATURE_SAMPLING; UART_USE_CALLBACK=0; PROCESS_SERIAL_DATA; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=TRUE; PLUS_BROADCASTER; DEVINFO_PID=0x0000
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\Source; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\SimpleProfile; ..\..\Profiles\SimpleProfile\CC254x; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; $OBJ_DIR$
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueBattery "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueBattery BlueBattery
configuration BlueSteca (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueSteca"; kMfrName="blue-battery.com"; DEVINFO_PID=0x0500; BLUESOLAR=TRUE; BLUESTECA=TRUE; INT_HEAP_LEN=4400; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xHAL_UART=TRUE; xHAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=0; HAL_UART_DMA_TX_MAX=0; HAL_I2C=TRUE; HAL_I2C_SLAVE; HAL_I2C_BUF_MAX=7; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; FEATURE_BOOST_CONVERTER=P2_0
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueSteca "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueSteca BlueSteca
configuration BlueBattery-D1 (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4400; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=32; HAL_UART_ISR=2; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; xFEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=0; PROCESS_SERIAL_DATA; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=FALSE; PLUS_BROADCASTER; FEATURE_SAMPLING
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueBattery-D1 "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueBattery-D1 BlueBattery-D1
configuration BlueBattery-MPPT (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4400; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=2; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=16; HAL_UART_ISR_RX_MAX=32; HAL_UART_ISR_TX_MAX=16; HAL_UART_ISR=1; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=FALSE; xFEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=1; PROCESS_SERIAL_DATA; PROCESS_MPPT; MPPT_AS_VOT=0; MPPT_DEVICES=1; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=FALSE; PLUS_BROADCASTER; FEATURE_SAMPLING; xFEATURE_TRUE_RMS
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BB-MPPT "$OBJ_DIR$" BlueBattery-MPPT.version
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueBattery-MPPT BlueBattery-MPPT
configuration BlueBattery-MPPT-CC-Debugger (8051)
  as the first configuration, except:
  ICC8051.CCDefines: xDEBUG_SERIAL=1000000; kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4400; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=48; HAL_UART_DMA_TX_MAX=16; HAL_UART_ISR_RX_MAX=32; HAL_UART_ISR_TX_MAX=16; HAL_UART_ISR=2; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=FALSE; xFEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=1; PROCESS_SERIAL_DATA; PROCESS_MPPT; MPPT_AS_VOT=0; MPPT_DEVICES=1; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=FALSE; PLUS_BROADCASTER; FEATURE_SAMPLING; FLASHSTORE_RES_AREA=14
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueBattery-MPPT "$OBJ_DIR$"
  postbuild: as above
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB-CC-Debugger.xcl
configuration BBX (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4656; BLUEBASIC_MEM=3328; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=2; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=16; HAL_UART_ISR=1; HAL_UART_ISR_RX_MAX=32; HAL_UART_ISR_TX_MAX=16; HAL_I2C=TRUE; xHAL_I2C_SLAVE; xHAL_I2C_BUF_MAX=7; HAL_I2C_MASTER=TRUE; xPOWER_SAVING; PLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=FALSE; xFEATURE_BOOST_CONVERTER=P2_0; FEATURE_SAMPLING; FEATURE_TRUE_RMS; UART_USE_CALLBACK=1; PROCESS_SERIAL_DATA; PROCESS_MPPT; MPPT_AS_VOT=1; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=FALSE; OS_AUTORUN_TIMEOUT=5000; DEVINFO_PID=0x2000; GAPROLE_DEFAULT_ADV_ENABLED=FALSE; FLASHSTORE_RES_AREA=0; FLASHSTORE_1STPAGE=70; FLASHSTORE_NRPAGES=10
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueBattery-BBX "$OBJ_DIR$" BlueBasic-BBX.version
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA-BBX  BBX BBX BBX
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB-BBX.xcl
configuration BBX-CC-Debugger (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4656; BLUEBASIC_MEM=3328; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=2; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=16; HAL_UART_ISR_RX_MAX=32; HAL_UART_ISR_TX_MAX=16; HAL_UART_ISR=1; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=FALSE; xFEATURE_BOOST_CONVERTER=P2_0; FEATURE_SAMPLING; FEATURE_TRUE_RMS; UART_USE_CALLBACK=1; PROCESS_SERIAL_DATA; PROCESS_MPPT; MPPT_AS_VOT=1; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=FALSE; PLUS_BROADCASTER; OS_AUTORUN_TIMEOUT=5000; DEVINFO_PID=0x2000; GAPROLE_DEFAULT_ADV_ENABLED=FALSE; FLASHSTORE_RES_AREA=16; FLASHSTORE_1STPAGE=70; FLASHSTORE_NRPAGES=10
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueBattery-BBX-CC "$OBJ_DIR$" BlueBasic-BBX-CC.version
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB-BBX-CC-Debugger.xcl
configuration BlueBattery-D1-CC-Debugger (8051)
  as the first configuration, except:
  ICC8051.CCDefines: xDEBUG_SERIAL=1000000; FLASHSTORE_RES_AREA=14; kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4400; BLUEBASIC_MEM=3072; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=32; HAL_UART_ISR=2; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; xFEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=0; PROCESS_SERIAL_DATA; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=FALSE; PLUS_BROADCASTER; FEATURE_SAMPLING
  ICC8051.CCIncludePath2: as above
  prebuild: as above
  postbuild: as above
  XLINK.XclFile: as above
configuration BlueBattery-Calibration (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueBattery"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4656; BLUEBASIC_MEM=3328; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=2; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=16; HAL_UART_ISR=1; HAL_UART_ISR_RX_MAX=32; HAL_UART_ISR_TX_MAX=16; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; xPOWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=FALSE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=TRUE; xFEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=0; PROCESS_SERIAL_DATA; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=TRUE; PLUS_BROADCASTER; FEATURE_SAMPLING; FEATURE_CALIBRATION; xFEATURE_TRUE_RMS; OS_AUTORUN_TIMEOUT=5000; DEVINFO_PID=0x2000; GAPROLE_DEFAULT_ADV_ENABLED=FALSE; FLASHSTORE_RES_AREA=0; FLASHSTORE_1STPAGE=70; FLASHSTORE_NRPAGES=10
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueBattery-Calibration "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueBattery-Calibration BlueBattery-Calibration
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB-BBX.xcl
configuration 2MPPT (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="2MPPT"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4656; BLUEBASIC_MEM=3328; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=32; HAL_UART_ISR=2; HAL_UART_ISR_RX_MAX=32; HAL_UART_ISR_TX_MAX=32; HAL_I2C=TRUE; xHAL_I2C_SLAVE; xHAL_I2C_BUF_MAX=7; HAL_I2C_MASTER=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=FALSE; xFEATURE_BOOST_CONVERTER=P2_0; xFEATURE_SAMPLING; xFEATURE_TRUE_RMS; UART_USE_CALLBACK=1; PROCESS_SERIAL_DATA; PROCESS_MPPT; MPPT_AS_VOT=0; MPPT_DEVICES=2; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=FALSE; OS_AUTORUN_TIMEOUT=5000; DEVINFO_PID=0x1100; GAPROLE_DEFAULT_ADV_ENABLED=FALSE; FLASHSTORE_RES_AREA=0; FLASHSTORE_1STPAGE=70; FLASHSTORE_NRPAGES=10
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" 2MPPT "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  2MPPT 2MPPT
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB-BBX.xcl
configuration BlueSun-X1 (8051)
  as the first configuration, except:
  ICC8051.CCDefines: kProduct="BlueSun-X1"; kMfrName="blue-battery.com"; BLUEBATTERY=TRUE; INT_HEAP_LEN=4656; BLUEBASIC_MEM=3328; BLUEBASIC=TRUE; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=1; HAL_UART_DMA_RX_MAX=32; HAL_UART_DMA_TX_MAX=32; HAL_UART_ISR_RX_MAX=32; HAL_UART_ISR_TX_MAX=32; HAL_UART_ISR=2; HAL_I2C=TRUE; xHAL_I2C_SLAVE; xHAL_I2C_BUF_MAX=7; HAL_I2C_MASTER=TRUE; xPOWER_SAVING; PLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; HAL_AES=FALSE; GAP_BOND_MGR=FALSE; FEATURE_DEVINFO=TRUE; TARGET_CC2541=TRUE; xFEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_B; OAD_IMAGE_VERSION=2; FEATURE_OAD_HEADER=FALSE; xFEATURE_BOOST_CONVERTER=P2_0; UART_USE_CALLBACK=1; PROCESS_SERIAL_DATA; xPROCESS_MPPT; MPPT_AS_VOT=0; xMPPT_DEVICES=2; OSALMEM_METRICS=FALSE; ENABLE_SNV=1; ENABLE_SPI=0; ENABLE_WIRE=0; XOSC32K_INSTALLED=FALSE; xFEATURE_SAMPLING; xFEATURE_TRUE_RMS; OS_AUTORUN_TIMEOUT=5000; DEVINFO_PID=0x0600; GAPROLE_DEFAULT_ADV_ENABLED=FALSE; FLASHSTORE_RES_AREA=0; FLASHSTORE_1STPAGE=70; FLASHSTORE_NRPAGES=10
  prebuild: "..\..\common\CC2540\timestamp.bat" "$PROJ_DIR$" BlueSun-X1 "$OBJ_DIR$"
  postbuild: "..\..\common\CC2540\convert-and-merge.bat" "$PROJ_DIR$" CC2541-ImgA  BlueSun-X1 BlueSun-X1
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB-BBX.xcl
  group APP
    ../Source/: BlueBasic.c BlueBasic.h BlueBasic_Flashstore.c BlueBasic_Interpreter.c BlueBasic_Main.c cc2540.asm os.c os.h OSAL_BlueBasic.c victron_mppt.c
  group Convert&Merge
    ../../common/cc2540/: convert-and-merge.bat timestamp.bat
  group HAL/Common
    ../../../../COMPONENTS/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_led.c
    ../../../../COMPONENTS/hal/target/CC2540EB/: hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2541ARC/Drivers
    ../../../../COMPONENTS/hal/target/CC2541ARC/: hal_i2c.c
  group HAL/Target/CC2541ARC/Includes
    ../../../../Components/hal/target/CC2541ARC/: hal_i2c.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib CC2541_BLE_peri_observ.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../COMPONENTS/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../COMPONENTS/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../COMPONENTS/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/Roles/CC254x/: observer.c observer.h peripheral.c peripheral.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
  group XLINK
    ../../common/cc2540/: cc254x_f256_imgB-CC-Debugger.xcl

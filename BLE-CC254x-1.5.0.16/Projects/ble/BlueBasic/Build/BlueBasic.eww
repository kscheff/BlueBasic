<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BlueBasic.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>BlueBasic</project>
                <configuration>BBX</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery-D1</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery-MPPT</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSolar</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSteca</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery-Calibration</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSolar_sleep</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>2MPPT</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSun-X1</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BBX-Rapid</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>BlueBattery &amp; BlueSolar &amp; BlueSteca</name>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSolar</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSteca</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery-D1</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery-MPPT</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BBX</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSun-X1</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSolar_sleep</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>2MPPT</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BBX-Rapid</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>BlueBattery &amp; BlueSolar</name>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSolar</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery-D1</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueBattery-MPPT</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BBX</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSolar_sleep</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BlueSun-X1</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BBX-Runtime</configuration>
            </member>
            <member>
                <project>BlueBasic</project>
                <configuration>BBX-Rapid</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
